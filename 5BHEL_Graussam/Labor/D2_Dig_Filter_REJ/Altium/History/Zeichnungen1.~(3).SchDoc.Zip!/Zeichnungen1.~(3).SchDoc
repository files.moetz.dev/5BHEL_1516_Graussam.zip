# Altium schematic sheet Zeichnungen1.~(3).SchDoc
size A4

## Notes on the sheet
- Audioplatine
- ARM Minimalsystem