# Altium schematic sheet Zeichnungen1.~(4).SchDoc
size A4

## Notes on the sheet
- IN
- Audioplatine
- OUT
- CM3
- ARM Minimalsystem