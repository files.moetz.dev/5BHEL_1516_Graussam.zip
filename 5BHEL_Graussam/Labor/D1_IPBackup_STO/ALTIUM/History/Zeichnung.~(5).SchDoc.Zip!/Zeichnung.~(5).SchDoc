# Altium schematic sheet Zeichnung.~(5).SchDoc
size A4

## Notes on the sheet
- OS Alt