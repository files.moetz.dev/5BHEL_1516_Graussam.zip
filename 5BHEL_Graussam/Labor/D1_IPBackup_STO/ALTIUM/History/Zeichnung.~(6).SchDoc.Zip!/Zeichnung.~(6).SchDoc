# Altium schematic sheet Zeichnung.~(6).SchDoc
size A4

## Notes on the sheet
- OS Alt
- OS Neu